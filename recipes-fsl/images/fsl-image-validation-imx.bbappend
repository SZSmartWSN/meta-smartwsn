# Copyright (C) 2019 Shenzhen SmartWSN Technology CO., Ltd.

IMAGE_INSTALL += " \
    protobuf \
    protobuf-lite \
    protobuf-c \
    paho-mqtt-c \
    libmodbus \
    libsnap7 \
    rtl8188eu-driver \
"
