DEFAULT_PREFERENCE = "1"

BBCLASSEXTEND = "native nativesdk"
